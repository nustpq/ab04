# IAR project libstoragemedia.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: sam9g25 Atmel sam9g25
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sama5d3x; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../../libboard_sama5d3x-ek; ../../; ../../../libchip_sama5d3x/; ../../../libstoragemedia/; ../../../libsdmmc/; ../../../libstoragemedia/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: sama5d3x
  ILINK.IlinkOutputFile: libstoragemedia.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sama5d3x
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: libstoragemedia.h
  group include
    ../../include/: Media.h MedRamDisk.h
  group source
    ../../source/: Media.c MEDRamDisk.c MEDSdcard.c
