# IAR project libchip_sama5d3x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAMA5D35 Atmel SAMA5D35
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sama5d3x; TRACE_LEVEL=1
  ICCARM.CCIncludePath2: ../../; ../../cp15; ../../../usb/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: libchip_sama5d3x.srec
  ILINK.IlinkOutputFile: libchip_sama5d3x.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sama5d3x
  AARM.ADefines: sama5d3x
  group (top)
    ../../: chip.h
  group cp15
    ../../cp15/: core.h cp15.c cp15.h cp15_asm_iar.s
  group include
    ../../include/: adc.h aes.h async.h can.h dacc.h dmac.h emac.h fuse.h gmac.h hsmci.h irq.h isi.h mmu.h pio.h pio_capture.h pio_it.h pit.h pmc.h pwmc.h rstc.h rtc.h SAMA5D3X.h sha.h smcNfc.h spi.h spi_pdc.h ssc.h tc.h tdes.h trace.h trng.h twi.h twid.h usart.h video.h wdt.h
  group source
    ../../source/: adc.c aes.c aic.c async.c can.c dmac.c emac.c fuse.c gmac.c hsmci.c isi.c mmu.c pio.c pio_it.c pit.c pmc.c pwmc.c rstc.c rtc.c sha.c smcNfc.c spi.c ssc.c tc.c tdes.c trng.c twi.c twid.c usart.c USBD_HAL.c video.c wdt.c
