# IAR project liblwip.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAMA5D3X Atmel SAMA5D3X
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sama5d3x; TRACE_LEVEL=1
  ICCARM.CCIncludePath2: ../../../libboard_sama5d3x-ek; ../../; ../../../libchip_sama5d3x/; ../../../liblwip/source/lwip_1.3.2/src/include; ../../../liblwip/source/lwip_1.3.2/src/include/lwip; ../../../liblwip/source/lwip_1.3.2/src//include/ipv4; ../../../liblwip/source/sama5-specific
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: sam9n12
  ILINK.IlinkOutputFile: liblwip.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sama5d3x
  ICCARM.CCOptLevel: 3
  group source/api
    ../../source/lwip_1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group source/core
    ../../source/lwip_1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group source/core/ipv4
    ../../source/lwip_1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group source/core/snmp
    ../../source/lwip_1.3.2/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group source/netif
    ../../source/lwip_1.3.2/src/netif/: etharp.c ethernetif.c slipif.c
  group source/sama5-specific
    ../../source/sama5-specific/: emacif.c gmacif.c
  group source/sama5-specific/arch
    ../../source/sama5-specific/arch/: sys_arch.c
