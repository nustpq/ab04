# IAR project libspiflash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9N12 Atmel SAM9N12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sama5d3x; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../../libboard_sama5d3x-ek; ../../; ../../../libchip_sama5d3x/; ../../../libspiflash/
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: sam9n12
  ILINK.IlinkOutputFile: libspiflash.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sama5d3x
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: board.h
  group include
    ../../include/: at25_spi.h at25d.h at45_spi.h at45d.h spi_dma.h
  group source
    ../../source/: at25_spi.c at25d.c at45_spi.c at45d.c spid_dma.c
