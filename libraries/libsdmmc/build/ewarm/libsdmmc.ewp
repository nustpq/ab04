# IAR project libsdmmc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9N12 Atmel SAM9N12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sama5d3x; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../../libboard_sama5d3x-ek; ../../; ../../../libchip_sama5d3x/; ../../../libsdmmc/; ../../../libsdmmc/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: sam9n12
  ILINK.IlinkOutputFile: libsdmmc.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sama5d3x
  ICCARM.CCIncludePath2: ../../; ../../../libchip_sama5d3x/; ../../../libsdmmc/; ../../../libsdmmc/include/
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: libsdmmc.h
  group include
    ../../include/: sdio.h sdmmc.h sdmmc_cmd.h sdmmc_dbg.h sdmmc_hal.h sdmmc_trace.h
  group source
    ../../source/: sdmmc.c
