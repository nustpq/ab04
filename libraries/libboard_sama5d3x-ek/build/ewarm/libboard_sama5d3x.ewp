# IAR project libboard_sama5d3x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAMA5D35 Atmel SAMA5D35
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sama5d3x; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../; ../../../libchip_sama5d3x/; ../../../libsdmmc/
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: sama5d3x
  ILINK.IlinkOutputFile: libboard_sama5d3x.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sama5d3x; TRACE_LEVEL=3
  group (top)
    ../../: board.h
  group include
    ../../include/: bitbanding.h bmp.h board_lowlevel.h board_memories.h cand.h clock.h dbg_util.h dmad.h emacd.h gmacb.h gmacd.h hamming.h iso7816_4.h lcd_color.h lcd_font.h lcd_font10x14.h lcdd.h led.h macb.h math.h mcid.h mii.h omnivision.h ov.h ovyuv.h rand.h uart_console.h wav.h wm8904.h
  group source
    ../../source/: bmp.c board_cstartup_iar.s board_lowlevel.c board_memories.c cand.c clock.c dbg_util.c dbgu_console.c dma_hardware_interface.c dmad.c emacd.c gmacb.c gmacd.c hamming.c iso7816_4.c lcd_draw.c lcd_font.c lcd_font10x14.c lcdd.c led.c macb.c math.c mcid_dma.c omnivision.c ov.c ov2640_config.c ov2643_config.c ov5640_config.c ov7740_config.c ov9740_config.c rand.c timetick.c trace.c tsd_com.c tsd_tsadc.c wav.c wm8904.c
