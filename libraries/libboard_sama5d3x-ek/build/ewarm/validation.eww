<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libboard_sama5d3x.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>build_all</name>
      <member>
        <project>libboard_sama5d3x-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sama5d3x-ek</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


