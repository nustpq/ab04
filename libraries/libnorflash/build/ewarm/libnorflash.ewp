# IAR project libnorflash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9N12 Atmel SAM9N12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sama5d3x; TRACE_LEVEL=1
  ICCARM.CCIncludePath2: ../../../libboard_sama5d3x-ek; ../../; ../../../libchip_sama5d3x/; ../../../libnorflash/
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: sam9n12
  ILINK.IlinkOutputFile: libnorflash.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sama5d3x
  group (top)
    ../../: board.h
  group include
    ../../include/: NorFlashAmd.h NorFlashApi.h NorFlashCFI.h NorFlashCommon.h NorFlashIntel.h
  group source
    ../../source/: NorFlashAmd.c NorFlashApi.c NorFlashCFI.c NorFlashCommon.c NorFlashIntel.c
