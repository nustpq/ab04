# IAR project uCOS-II.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAMA5D35 Atmel SAMA5D35
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sama5d3x; CUSTOM_USB; USE_DMA
  ICCARM.CCIncludePath2: ..\; ..\..\BSP; ..\..\BSP\uCOS-II; ..\..\BSP\IAR; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-CPU\ARM-Cortex-A\IAR; ..\..\..\..\..\uC-LIB; ..\..\..\..\..\uC-LIB\Ports\ARM-Cortex-A\IAR; ..\..\..\..\..\uCOS-II\Source; ..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-A\Generic\IAR; ..\..\..\..\..\libraries\libboard_sama5d3x-ek; ..\..\..\..\..\libraries\libboard_sama5d3x-ek\include; ..\..\..\..\..\libraries\libchip_sama5d3x; ..\..\..\..\..\libraries\libchip_sama5d3x\include; ..\..\..\..\..\libraries\libchip_sama5d3x\include\component; ..\..\..\..\..\libraries\libchip_sama5d3x\include\instance; ..; ..\..\..\..\..\libraries\usb; ..\..\..\..\..\libraries\usb\include; ..\..\..\..\..\libraries\libnandflash; ..\..\..\..\..\libraries\libnandflash\include; ..\..\..\..\..\libraries\libpmecc; ..\..\..\..\..\libraries\libpmecc\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uCOS-II.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\sama5d3x-ek-ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../: MICRIUM_README.txt
  group Application
    ../: alert_table.c app.c app_cfg.h cmdParse.c cpu_cfg.h emb.c i2s.c i2s.h kfifo.c lib_cfg.h mem_basic.c object.h os_cfg.h uif_dsp.c uif_nandflash.c uif_spi.c uif_twi.c uif_usart.c usb.c USBDDriverDescriptors.c
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_cache.h bsp_int.c bsp_int.h cpu_bsp.c
    ../../BSP/IAR/: bsp_cache.s cstartup.s sama5d3x-ek-ddram.icf sama5d3x-ek-ddram.mac
    ../../BSP/uCOS-II/: bsp_os.c bsp_os.h
  group LIB
    ../../../../../libraries/libboard_sama5d3x-ek/lib/: libboard_sama5d3x_ek_ewarm_dbg.a libboard_sama5d3x_ek_ewarm_rel.a
    ../../../../../libraries/libchip_sama5d3x/lib/: libchip_sama5d3x_ewarm_dbg.a libchip_sama5d3x_ewarm_rel.a
    ../../../../../libraries/libnandflash/lib/: libnandflash_ewarm_dbg.a
    ../../../../../libraries/libpmecc/lib/: libpmecc_ewarm_dbg.a
    ../../../../../libraries/usb/lib/: libusb_ewarm_dbg.a libusb_ewarm_rel.a
  group uC-CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC-CPU/ARM-Cortex-A
    ../../../../../uC-CPU/ARM-Cortex-A/IAR/: cpu.h cpu_a.asm
  group uC-LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC-LIB/ARM
    ../../../../../uC-LIB/Ports/ARM/IAR/: lib_mem_a.asm
  group uC/OS-II
    ../../../../../uCOS-II/Source/: os_cfg_r.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/OS-II/ARM-Cortex-A
    ../../../../../uCOS-II/Ports/ARM-Cortex-A/Generic/IAR/: os_cpu.h os_cpu_a_vfp-d16.asm os_cpu_c.c
