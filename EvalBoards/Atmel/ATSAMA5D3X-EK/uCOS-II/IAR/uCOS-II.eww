<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\libraries\libboard_sama5d3x-ek\build\ewarm\libboard_sama5d3x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\libraries\libchip_sama5d3x\build\ewarm\libchip_sama5d3x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\libraries\usb\build\ewarm\libusb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uCOS-II.ewp</path>
  </project>
  <batchBuild/>
</workspace>


